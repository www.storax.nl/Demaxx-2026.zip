Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 616c0d12-5a23-444b-8182-2398694e1f55.ifc
Time: 2026-08-11T10:54:12
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - DEMAXX 70/140
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 8,33 m²·k/w
Pset_Data - WUID: AgAAAOYX2IkFAAAAd4UCAAU4QgAAJVQBAInDAAB1hQIAeYUCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOYX2IkFAAAAd4UCAAU4QgAAJVQBAInDAAB1hQIAeYUCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 30.44.10; lengte: 1780 mm; weerstand tegen windbelasting: C5; dagmaatlengte: 1400 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 8,33 m²·k/w; garantieperiode: 10 jaar; breedte: 1080 mm; NAA.K.T: samengesteld_product_kozijn; theoretische levensduur: 75; serie: DEMAXX; merk: Storax; eenheid: st; type: 70/140; dagmaatbreedte: 700 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
