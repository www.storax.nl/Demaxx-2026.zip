Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: a1cc1c16-1812-46d0-bac6-586835f7dc5c.ifc
Time: 2026-08-11T10:54:37
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - DEMAXX 70/140 met ladderbeugel
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 8,33 m²·k/w
Pset_Data - WUID: AgAAAOYU2IkFAAAAd4UCAAU4QgAAJVQBAInDAAB1hQIAeoUCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOYU2IkFAAAAd4UCAAU4QgAAJVQBAInDAAB1hQIAeoUCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); uitvoering: met ladderbeugel; STABU2: 30.44.10; lengte: 1780 mm; weerstand tegen windbelasting: C5; dagmaatlengte: 1400 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 8,33 m²·k/w; garantieperiode: 10 jaar; breedte: 1080 mm; NAA.K.T: samengesteld_product_kozijn; theoretische levensduur: 75; serie: DEMAXX; merk: Storax; eenheid: st; type: 70/140; dagmaatbreedte: 700 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
