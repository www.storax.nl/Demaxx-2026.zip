Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 9176e265-fba2-40f7-a9c5-308cf8a1eefa.ifc
Time: 2026-08-11T10:58:53
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - DEMAXX 90/90 met ladderbeugel
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 8,33 m²·k/w
Pset_Data - WUID: AgAAAOYS2IkFAAAAd4UCAAU4QgAAJVQBAInDAAB1hQIAfIUCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOYS2IkFAAAAd4UCAAU4QgAAJVQBAInDAAB1hQIAfIUCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); uitvoering: met ladderbeugel; STABU2: 30.44.10; lengte: 1280 mm; weerstand tegen windbelasting: C5; dagmaatlengte: 900 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 8,33 m²·k/w; garantieperiode: 10 jaar; breedte: 1280 mm; NAA.K.T: samengesteld_product_kozijn; theoretische levensduur: 75; serie: DEMAXX; merk: Storax; eenheid: st; type: 90/90; dagmaatbreedte: 900 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
